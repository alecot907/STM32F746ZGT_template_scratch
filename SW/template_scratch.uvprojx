# Keil uVision project template_scratch.uvprojx, settings and files
target template_scratch (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: template_scratch +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F746xx
  c include: .\src\BSW\STM32F746ZG;.\src\BSW;.\src\BSW_CFG\STM32F746ZG;.\src\BSW_CFG;.\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group ASW
    ./src/: main.c
  group BSW
    ./src/BSW/STM32F746ZG/: ClockDrv.c ChipInfo.c RtcDrv.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.2.2
